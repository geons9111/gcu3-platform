SUMMARY = "GCU3 Version Recipe"

LICENSE = "MIT"

PV = "1.0.0"

do_install() {
    :
}
